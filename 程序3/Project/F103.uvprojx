# Keil uVision project F103.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\ANO_DT;..\User\delay;..\User\MPU6050;..\User\MPU6050\eMPL;..\User\sys;..\User\usart;..\User\exti;..\User\encoder;..\User\pwm;..\User\motor;..\User\pid;..\User\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/ANO_DT/: ANO_DT.c
    ../User/delay/: delay.c
    ../User/MPU6050/: mpu6050.c mpuiic.c
    ../User/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/sys/: sys.c
    ../User/usart/: usart.c
    ../User/exti/: exti.c
    ../User/encoder/: encoder.c
    ../User/pwm/: pwm.c
    ../User/motor/: motor.c
    ../User/pid/: pid.c
    ../User/oled/: oled.c
  group DOC
    ../Doc/: readme.txt
